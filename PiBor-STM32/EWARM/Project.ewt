<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM32100B-EVAL</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\CMSIS\core_cm3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CMSIS\system_stm32f10x.c</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\..\Startup\startup_stm32f10x_md.s</name>
    </file>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\StdPeriph_Driver\src\stm32f10x_usart.c</name>
    </file>
  </group>
  <group>
    <name>USB</name>
    <file>
      <name>$PROJ_DIR$\..\USB\LIB\usb_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USB\LIB\usb_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USB\LIB\usb_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USB\LIB\usb_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USB\LIB\usb_regs.c</name>
    </file>
  </group>
  <group>
    <name>USBCFG</name>
    <file>
      <name>$PROJ_DIR$\..\USB\CONFIG\hw_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USB\CONFIG\usb_desc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USB\CONFIG\usb_istr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USB\CONFIG\usb_prop.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\USB\CONFIG\usb_pwr.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\beep_pwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\usart.c</name>
    </file>
  </group>
</project>


